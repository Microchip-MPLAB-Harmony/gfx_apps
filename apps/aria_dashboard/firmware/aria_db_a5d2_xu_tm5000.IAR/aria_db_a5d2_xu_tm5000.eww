<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\aria_db_a5d2_xu_tm5000.ewp</path>
    </project>
    <batchBuild />
</workspace>
